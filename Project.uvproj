# Keil uVision project Project.uvproj, settings and files
target Target 1 (MCS-51)
  device: STC8H1K28 Series STC
  cpu: IRAM(0-0xFF) XRAM(0-0x03FF) IROM(0-0x6FF8) CLOCK(35000000)
  output: Project +hex
  c flags: Optimize=8 SizeSpeed=1
  c include: ./src/lib
  group Source Group 1
    ./src/: main.c
    ./src/src/: gui.c pt6315.c rx8025.c sys.c ws2812b.c
